<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>AVR</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>AVR</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <file>
    <name>$PROJ_DIR$\lgt8f328p_intr.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\lgt8f328p_misc.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\lgt8f328p_usart.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
</project>


